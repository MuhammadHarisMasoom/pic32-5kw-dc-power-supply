/**
  Section: Included Files
 */
#define SYS_FREQ _XTAL_FREQ // Running at 24MHz


#include "mcc_generated_files/system.h"
#include <xc.h>
#include <stdio.h>

uint8_t data_Global[10];
float ADC_val; /* ADC converted value*/

// Array of bytes which displays data through UART to display (0x10 is address to write for)
uint8_t data_to_display[8] = {0x5A, 0xA5, 0x05, 0x82, 0x10, 0x00, 0x04, 0x00};

//uint8_t data_send_to_display[7] = {0x5A, 0xA5, 0x04, 0x83, 0x10, 0x00, 0x01};

uint8_t keypad_buffer[11];

uint8_t data_from_display_py[2];


// **************** global variables for python display *****************************
uint16_t read_val_py;
uint16_t read_val_py1;
uint16_t lsb_11_bits_py;
uint16_t msb_5_bits_py;
uint16_t t;
uint8_t msb;
uint8_t lsb;

// *************************************************************

uint16_t data;
uint16_t data1;



//                         Main application

void delay_us(unsigned int us) {
    // Convert microseconds us into how many clock ticks it will take 
    us *= SYS_FREQ / 1000000 / 2; // Core Timer updates every 2 ticks

    _CP0_SET_COUNT(0); // Set Core Timer count to 0

    while (us > _CP0_GET_COUNT()); // Wait until Core Timer count reaches the number we calculated earlier
}

//*****************************************************************************
//*****************************************************************************
// I2C_init() initialises I2C1 at at frequency of [frequency]Hz  

void I2C_init(double frequency) {
    double BRG;

    I2C1CON = 0; // Turn off I2C1 module
    I2C1CONbits.DISSLW = 0; // Disable slew rate for 100kHz

    BRG = (1 / (2 * frequency)) - 0.000000139;
    BRG *= (SYS_FREQ) - 2;

    I2C1BRG = (int) BRG; // Set baud rate
    I2C1CONbits.A10M = 0; // 7 bit slave address
    I2C1CONbits.ON = 1; // Turn on I2C1 module
}


// I2C_wait_for_idle() waits until the I2C peripheral is no longer doing anything  

void I2C_wait_for_idle(void) {
    uint16_t local_count = 0;
    while (I2C1CON & 0x1F); // Acknowledge sequence not in progress
    // Receive sequence not in progress
    // Stop condition not in progress
    // Repeated Start condition not in progress
    // Start condition not in progress
    //    while(I2C1STATbits.TRSTAT); // Bit = 0 ? Master transmit is not in progress
    do {
        local_count++;
        if (local_count > 65530) return;
    } while (I2C1STATbits.TRSTAT == 1); // Wait until ACK is received   
}

// I2C_start() sends a start condition  

void I2C_start() {
    I2C_wait_for_idle();
    I2C1CONbits.SEN = 1;
    while (I2C1CONbits.SEN == 1);
    I2C_wait_for_idle();
}

// I2C_stop() sends a stop condition  

void I2C_stop() {
    I2C_wait_for_idle();
    I2C1CONbits.PEN = 1;
}

// I2C_restart() sends a repeated start/restart condition

void I2C_restart() {
    I2C_wait_for_idle();
    I2C1CONbits.RSEN = 1;
    while (I2C1CONbits.RSEN == 1);
}

// I2C_ack() sends an ACK condition

void I2C_ack(void) {
    I2C_wait_for_idle();
    I2C1CONbits.ACKDT = 0; // Set hardware to send ACK bit
    I2C1CONbits.ACKEN = 1; // Send ACK bit, will be automatically cleared by hardware when sent  
    while (I2C1CONbits.ACKEN); // Wait until ACKEN bit is cleared, meaning ACK bit has been sent
}

// I2C_nack() sends a NACK condition

void I2C_nack(void) // Acknowledge Data bit
{
    I2C_wait_for_idle();
    I2C1CONbits.ACKDT = 1; // Set hardware to send NACK bit
    I2C1CONbits.ACKEN = 1; // Send NACK bit, will be automatically cleared by hardware when sent  
    while (I2C1CONbits.ACKEN); // Wait until ACKEN bit is cleared, meaning NACK bit has been sent
}

// address is I2C slave address, set wait_ack to 1 to wait for ACK bit or anything else to skip ACK checking  

void I2C_write(unsigned char address, char wait_ack, char RW) {
    uint16_t local_count = 0;
    I2C1TRN = address | RW; // Send slave address with Read/Write bit cleared
    //    LATBbits.LATB14 = 1;
    while (I2C1STATbits.TBF == 1) { // Wait until transmit buffer is empty
        //        while (I2C1STATbits.BCL == 1);
    }


    I2C_wait_for_idle(); // Wait until I2C bus is idle

    if (wait_ack) {
        do {
            local_count++;
            if (local_count > 65530) return;
        } while (I2C1STATbits.ACKSTAT == 1); // Wait until ACK is received   
    }

}
// value is the value of the data we want to send, set ack_nack to 0 to send an ACK or anything else to send a NACK  

void I2C_read(unsigned char *value, char ack_nack) {
    I2C1CONbits.RCEN = 1; // Receive enable
    while (I2C1CONbits.RCEN); // Wait until RCEN is cleared (automatic)  
    while (!I2C1STATbits.RBF); // Wait until Receive Buffer is Full (RBF flag)  
    *value = I2C1RCV; // Retrieve value from I2C1RCV

    if (!ack_nack) // Do we need to send an ACK or a NACK?  
        I2C_ack(); // Send ACK  
    else
        I2C_nack(); // Send NACK  
}


//******************************************************************************
/*        I2C data read from Sensirion SHT4xI Temp. and Humidity Sensor       */

/*
 * The following function will read the Sensirion Sensor data of Temperature
 * and Humidity on IC bus. The address code is factory configured to 0x44.
 */

void Temp_Hum_sensor() {

    delay_us(100);
    I2C_start(); /* Send start condition */
    I2C_write(0x44 << 1, 1, 0); /* Send address with ACK status, write = 0 */
    I2C_write(0xFD, 1, 0);
    I2C_stop();

    delay_us(7000); /* wait for 10ms as recommended in data sheet. */
    /* Start reading the sensor data */
    I2C_start();
    /* If conversion is still in progress the sensor do not send ACK. So, ACK will be checked here manually. */
    I2C_write(0x44 << 1, 1, 1); /* Send address with not ACK status, R/W = 1, means read data */

    I2C_read(&data_Global[1], 0); /* Read the Conversion MSB byte and ack it*/
    I2C_read(&data_Global[0], 0); /* Read the Conversion LSB byte and ack it*/
    I2C_read(&data_Global[2], 0); /* Read the Conversion LSB byte and  ack it (Temp. data checksum) */

    I2C_read(&data_Global[4], 0); /* Read the Conversion MSB byte and ack it*/
    I2C_read(&data_Global[3], 0); /* Read the Conversion LSB byte and ack it*/
    I2C_read(&data_Global[5], 1); /* Read the Conversion LSB byte and not ack it (humidity data checksum) */

    I2C_stop();

    /*
     * The following code will convert received data to Temperature in C and 
     * relative humidity as formulas given in sensor data sheet. 
     */

    /* Temperature Conversion*/
    //        ADC_val = data_Global[1]*256 + data_Global[0];
    //        ADC_val = -45 + (175 * ADC_val) / 65535; // In Centigrade
    //    sprintf(Temp_Humidity_Measured_Data_str[0], "%.1f", ADC_val); // Temp. in string format


    /* Relative Humidity Conversion*/
    ADC_val = data_Global[4]*256 + data_Global[3];
    ADC_val = -6 + (125 * ADC_val) / 65535; // In %RH
    //        sprintf(Temp_Humidity_Measured_Data_str[1], "%.1f", ADC_val); // %RH in string format

    /**********************Sending values through UART to DWIN Display*******************************/
    uint16_t t = ADC_val * 100; // multiplying by 100 will convert the float value to 16 bit integer

    // Extract MSB and LSB
    uint8_t msb = (t >> 8) & 0xFF; // Shift right by 8 bits and mask with 0xFF
    uint8_t lsb = t & 0xFF;

    data_to_display[6] = msb;
    data_to_display[7] = lsb;

    for (uint8_t i = 0; i < 8; i++) {
        UART2_Write(data_to_display[i]); /* Temp. data */
        delay_us(1000);
    }
}


// *****************************************************************************
// ************************ Power Supply Project *******************************

void enable_all_writeable_registors() {
    delay_us(100);
    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(0x10, 1, 0); // 0x10 Write enable register must set to 0x00 to enable write commands to writable registers
    I2C_write(0x00, 1, 0); // 0x00--> enables all writable registers
    I2C_stop(); // Sending stop bit to slave to stop communication
}

//******************************************************************************

// *****************************************************************************
//               Reading and Writing data from Python Display

// *****************************************************************************
//                  Code to turn ON power supply

void write_ON_on_power_supply_py(uint8_t on) {
    enable_all_writeable_registors();

    /*This block of code turn the power supply on or off according to need*/
    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(0x01, 1, 0); // 0x01 OPERATION (ON, OFF Control)
    I2C_write(on, 1, 0); // 0x80: Turn ON, 0x00: Turn OFF
    I2C_stop(); // Sending stop bit to slave to stop communication
    //    delay_us(100);
}

// *****************************************************************************
//                  Code to turn OFF power supply

void write_OFF_on_power_supply_py(uint8_t off) {
    enable_all_writeable_registors();

    /*This block of code turn the power supply on or off according to need*/
    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(0x01, 1, 0); // 0x01 OPERATION (ON, OFF Control)
    I2C_write(off, 1, 0); // 0x80: Turn ON, 0x00: Turn OFF
    I2C_stop(); // Sending stop bit to slave to stop communication
    //    delay_us(100);
}

// *****************************************************************************
//                  Code to turn FACTORY RESET power supply

void write_factory_reset_on_power_supply_py(uint8_t factory_reset) {

    enable_all_writeable_registors();

    /*Restore factory settings*/
    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(factory_reset, 1, 0); // FACTORY RESET
    I2C_stop(); // Sending stop bit to slave to stop communication
    delay_us(1000);
}


// *****************************************************************************
// Code to set desired VOLTAGE and display the set VOLTAGE

void read_voltage_from_power_supply_py() {

    //    uint16_t read_voltage;

    /*Reading Output Voltage*/
    delay_us(700);
    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(0x8B, 1, 0); // 0x8B--> READ_VOUT
    //    delay_us(700);
    I2C_restart(); // Sending restart bit
    I2C_write(0xBE, 1, 1); // Sending Slave Address again, 1 to wait for acknowledge, 1 to read from slave
    I2C_read(&data_Global[0], 0); /* Reading LSB byte coming from Power Supply and ack it*/
    I2C_read(&data_Global[1], 1); /* Reading MSB byte coming from Power Supply and not ack it*/
    I2C_stop(); // Sending stop bit to slave to stop communication

    delay_us(100);
    UART2_Write('v');
    UART2_Write(data_Global[1]);
    UART2_Write(data_Global[0]);
}

void write_voltage_on_power_supply_py(uint8_t voltage_to_write) {

    enable_all_writeable_registors();

    /*Setting VOUT_COMMAND (Voltage Setting)*/
    delay_us(1000);
    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(0x21, 1, 0); // VOUT_COMMAND
    I2C_write(0x00, 1, 0); // sending LSB 
    I2C_write(voltage_to_write, 1, 0); // sending MSB (0x00 = 0V to 0xC8 = 200V)
    I2C_stop(); // Sending stop bit to slave to stop communication


    read_voltage_from_power_supply_py();
}

// *****************************************************************************
// Code to set desired CURRENT and display the set CURRENT

void read_current_from_power_supply_py() {

    /*Reading Output Current*/
    delay_us(700);
    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(0x46, 1, 0); // reading current
    I2C_restart(); // Sending restart bit
    I2C_write(0xBE, 1, 1); // Sending Slave Address again, 1 to wait for acknowledge, 1 to read from slave
    I2C_read(&data_Global[0], 0); /* Reading LSB byte coming from Power Supply and ack it*/
    I2C_read(&data_Global[1], 1); /* Reading MSB byte coming from Power Supply and not ack it*/
    I2C_stop(); // Sending stop bit to slave to stop communication

    delay_us(1000);
    UART2_Write('i');
    UART2_Write(data_Global[0]);
    UART2_Write(0x00);
}

void write_current_on_power_supply_py(uint8_t current_to_write) {

    enable_all_writeable_registors();

    /*Setting Current Limit*/
    delay_us(1000);
    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(0x46, 1, 0); // IOUT_OC_FAULT_LIMIT
    I2C_write(current_to_write, 1, 0); // sending LSB
    I2C_write(0x00, 1, 0); // sending MSB 
    I2C_stop(); // Sending stop bit to slave to stop communication

    read_current_from_power_supply_py();
}

// *****************************************************************************
// Code to set desired TEMPERATURE and display the set TEMPERATURE

void read_temperature_from_power_supply_py() {
    // check the read temperature register (Parameter to read)
    uint16_t read_temperature;

    /*Reading Temperature*/
    delay_us(700);
    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(0x8D, 1, 0); // reading temp of zone 1
    I2C_restart(); // Sending restart bit
    I2C_write(0xBE, 1, 1); // Sending Slave Address again, 1 to wait for acknowledge, 1 to read from slave
    I2C_read(&data_Global[0], 0); /* Reading LSB byte coming from Power Supply and ack it*/
    I2C_read(&data_Global[1], 1); /* Reading MSB byte coming from Power Supply and not ack it*/
    I2C_stop(); // Sending stop bit to slave to stop communication

    read_temperature = data_Global[1]*256 + data_Global[0];

    // Extract the 11 LSB
    uint16_t lsb_11_bits = read_temperature & 0x07FF; // Mask with 0x07FF (0000011111111111 in binary)
    //
    //    // Extract the 5 MSB
    uint16_t msb_5_bits = (read_temperature >> 11) & 0x001F; // Shift right by 11 and mask with 0x001F (0000000000011111 in binary)

    read_temperature = lsb_11_bits * (1 << msb_5_bits); // This is according to reference manual of power supply

    delay_us(1000);
    UART2_Write('t');
    UART2_Write(0x32);

}

void write_temperature_on_power_supply_py(uint8_t temperature_to_write) {
    read_temperature_from_power_supply_py();
}

// *****************************************************************************
// Code to set desired FAN SPEED and display the set FAN SPEED

void read_fan_speed_from_power_supply_py() {
    /*Reading Output Current*/
    delay_us(700);
    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(0x90, 1, 0); // reading current
    I2C_restart(); // Sending restart bit
    I2C_write(0xBE, 1, 1); // Sending Slave Address again, 1 to wait for acknowledge, 1 to read from slave
    I2C_read(&data_Global[0], 0); /* Reading LSB byte coming from Power Supply and ack it*/
    I2C_read(&data_Global[1], 1); /* Reading MSB byte coming from Power Supply and not ack it*/
    I2C_stop(); // Sending stop bit to slave to stop communication

    read_val_py = data_Global[1]*256 + data_Global[0];

    lsb_11_bits_py = read_val_py & 0x07FF;

    msb_5_bits_py = (read_val_py >> 11) & 0x001F;

    read_val_py1 = lsb_11_bits_py * (1 << msb_5_bits_py);

    delay_us(100);
}

void write_fan_speed_on_power_supply_py(uint8_t fan_speed_to_write) {

    enable_all_writeable_registors();

    I2C_start(); // Sending Start bit from microcontroller
    I2C_write(0xBE, 1, 0); // Sending Address, 1 to wait for acknowledge, 0 to write
    I2C_write(0x3B, 1, 0); // FAN_COMMAND_1_2
    I2C_write(fan_speed_to_write, 1, 0); // sending LSB (Writing 0 will leave the entire fan control to power supply)
    I2C_write(0x00, 1, 0); // sending MSB 
    I2C_stop(); // Sending stop bit to slave to stop communication
    delay_us(100);

    //    read_fan_speed_from_power_supply_py();
}

// ****************************************************************************
// ****************************************************************************
//                functionality selection function

void funcitonality_selector_py() {

    for (uint8_t i = 0; i < 2; i++) {
        data_from_display_py[i] = UART2_Read();
        delay_us(1000);
    }

    if (data_from_display_py[0] == 'O') { // ON
        write_ON_on_power_supply_py(data_from_display_py[1]);

    } else if (data_from_display_py[0] == 'X') { // OFF
        write_OFF_on_power_supply_py(data_from_display_py[1]);
    } else if (data_from_display_py[0] == 'V') { // Voltage Write
        write_voltage_on_power_supply_py(data_from_display_py[1]);
    } else if (data_from_display_py[0] == 'I') { // Current Write
        write_current_on_power_supply_py(data_from_display_py[1]);
    } else if (data_from_display_py[0] == 'F') { // Fan speed write
        write_fan_speed_on_power_supply_py(data_from_display_py[1]);
    } else if (data_from_display_py[0] == 'Q') { // Factory reset write
        write_factory_reset_on_power_supply_py(data_from_display_py[1]);
    }
}

// *****************************************************************************
//              Code for testing read and write data on python display

//void test_read_write_data_py() {
//    uint8_t data;
//    data = UART2_Read();
//    delay_us(1000);
//    UART2_Write(data);
//    delay_us(1000);
//}

//**************************************************************************  
//******************************************************************************

/*                      UART 1 Interrupt Service Routine                      */
//void UART2_ISR(void) {
//    //    uint8_t data[2];
//    //    for (uint8_t i=0; i<2;i++){
//    //        data[i] = UART2_Read();
//    //    }
//    //    delay_us(1000);
//    funcitonality_selector_py();
//}

//************************************************************************** 
//************************************************************************** 

// void led_toggle() {
//    TRISCbits.TRISC0 = 0; // We have accessed only 1 bit from TRISB register as we only need to blink 1 LED            

//    while (1) {
//        LATCbits.LATC0 = 1;
//        delay_us(1000000);
//        LATCbits.LATC0 = 0;
//        delay_us(1000000);
//    };
//}

//************************************************************************** 
//************************************************************************** 

int main(void) {
    SYSTEM_Initialize();
    I2C_init(400000);
    //    LATC = 0xFF; // Turn OFF all the Converters //
    //    UART2_SetRxInterruptHandler(&UART2_ISR);
    //    IFS1CLR = _IFS1_AD1IF_MASK;

    while (1) {        // *********************************************************************
        //                              functionality selector

        funcitonality_selector_py();
    }

    return 1;

}
/*
 * Implement receive interrupt
 */